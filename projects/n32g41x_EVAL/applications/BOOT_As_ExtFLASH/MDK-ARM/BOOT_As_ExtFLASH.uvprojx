# Keil uVision project BOOT_As_ExtFLASH.uvprojx, settings and files
target N32G412 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G412RBL7 Nsingtech
  pack: Nsingtech.N32G41x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x06000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: BOOT_As_ExtFLASH +hex
  AfterMake: fromelf --bin --output=.\bin\BOOT_As_ExtFLASH.bin .\Objects\BOOT_As_ExtFLASH.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G412, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\bsp\inc;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\n32g41x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_n32g41x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32g41x.c
  group FWLB
    ../../../../../firmware/n32g41x_std_periph_driver/src/: misc.c n32g41x_flash.c n32g41x_gpio.c n32g41x_iwdg.c n32g41x_rcc.c n32g41x_usart.c
  group BSP
    ../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32g41x_it.c
target N32G415 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G415CBL7 Nsingtech
  pack: Nsingtech.N32G41x_DFP.1.0.0
  cpu: as above
  output: BOOT_As_ExtFLASH +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G415, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
