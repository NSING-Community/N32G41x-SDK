# Keil uVision project project.uvprojx, settings and files
target N32G412 (6160000::V6.16::ARMCLANG)
  device: N32G412RBL7 Nsingtech
  pack: Nsingtech.N32G41x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x06000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output=.\bin\project.bin .\Objects\project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G412, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g41x_std_periph_driver\inc;..\..\..\..\bsp\inc;..\inc;..\..\..\..\..\..\Middlewares\FreeRTOSv202604.01-LTS\FreeRTOS-Kernel\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g41x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g41x.c
  group FWLB
    ../../../../../../firmware/n32g41x_std_periph_driver/src/: misc.c n32g41x_gpio.c n32g41x_rcc.c n32g41x_usart.c
  group FreeRTOS\Source
    ../../../../../../Middlewares/FreeRTOSv202604.01-LTS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\Source\portable
    ../../../../../../Middlewares/FreeRTOSv202604.01-LTS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../src/: port_select.c
  group USER
    ../src/: main.c n32g41x_it.c
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group DOC
    ../: readme.txt
target N32G415 (6160000::V6.16::ARMCLANG)
  device: N32G415RBL7 Nsingtech
  pack: Nsingtech.N32G41x_DFP.1.0.0
  cpu: as above
  output: project +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G415, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
