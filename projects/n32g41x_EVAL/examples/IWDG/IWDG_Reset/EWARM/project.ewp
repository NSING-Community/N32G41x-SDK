# IAR project project.ewp, settings and files
configuration N32G412 (ARM, debug)
  General.OGChipSelectEditMenu: N32G412xB Nsing N32G412xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: N32G412; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; LSI_TIM_MEASURE
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g41x_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32G415 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32G415xB Nsing N32G415xB
  ICCARM.CCDefines: N32G415; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; LSI_TIM_MEASURE
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g41x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g41x_std_periph_driver/src/: misc.c n32g41x_dbg.c n32g41x_gpio.c n32g41x_iwdg.c n32g41x_pwr.c n32g41x_rcc.c n32g41x_usart.c n32g41x_tim.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g41x_EWARM.S
  group USER
    ../src/: main.c n32g41x_it.c
