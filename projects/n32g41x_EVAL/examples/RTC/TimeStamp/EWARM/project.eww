<?xml version='1.0' encoding='utf-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\project.ewp</path>
  </project>
  <batchBuild><batchDefinition><name>N32G412</name><targets><target>$WS_DIR$\project.ewp/N32G412</target></targets></batchDefinition></batchBuild>
</workspace>